
PACKAGECONFIG_append = " libinput linuxfb"
PACKAGECONFIG_remove = " gl icu x11"
