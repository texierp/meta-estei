inherit estei-base-image
