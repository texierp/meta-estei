FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_zedboard-zynq7 += "file://defconfig"

