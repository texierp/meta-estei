FILESEXTRAPATHS_prepend := "${THISDIR}/features:"
SRC_URI += "file://logo.cfg"
