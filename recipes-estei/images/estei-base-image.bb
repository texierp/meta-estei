DESCRIPTION = "estei basic image."

inherit estei-base-image
